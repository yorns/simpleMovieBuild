
# cec-client installation missing for some wierd reason 
FILES_${PN} += "${bindir}/cec-client*"
